# IAR project INCLIX_F1_LCD_Interface_20260223_v1_0.ewp, settings and files
configuration INCLIX_F1_LCD_Interface_20260223_v1_0 (ARM, debug)
  General.OGChipSelectEditMenu: STM32G081CB ST STM32G081CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G081xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../USER/App/PowerControl_App; ../Drivers/STM32G0xx_HAL_Driver/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../Drivers/CMSIS/Include; ../USER; ../USER/Drive/PowerControl_Drv
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: INCLIX_F1_LCD_Interface_20260223_v1_0.hex
  ILINK.IlinkOutputFile: INCLIX_F1_LCD_Interface_20260223_v1_0.out
  ILINK.IlinkIcfFile: stm32g081xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g081xx.s
  group Application/User/App
    ../USER/App/PowerControl_App/: PowerControl_App.c
    ../USER/App/ImageSlide_App/: ImageSlide_App.c ImageSlide_Assets.c
  group Application/User/Core
    ../Core/Src/: main.c stm32g0xx_hal_msp.c stm32g0xx_it.c
  group Application/User/Drive
    ../USER/Drive/PowerControl_Drv/: PowerControl_Drv.c
    ../USER/Drive/OLED_SSD1322_Drv/: OLED_SSD1322_Drv.c
  group Application/User/UserMain
    ../USER/: User_Main.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_ll_rcc.c
